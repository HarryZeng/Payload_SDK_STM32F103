# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\STM32F10x_StdPeriph_Driver\inc;.\STM32F10x_StdPeriph_Driver\src;..\STM32F103;..\Payload_SDK_STM32F103_LED;.\Application;.\Application\psdk_test;.\psdk\psdk_upper\inc;.\psdk\psdk_upper\src;.\psdk\psdk_core\inc;.\psdk\psdk_core\src;.\BSP;.\psdk\psdk_arch\arch_baremetal;.\user
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group usr
    ./Application/: app_infor.h app_config.h application.c
    ./: main.c
    ./BSP/: dji_ringbuffer.c flash.c led_button_switch.c log_printf.c sys.c uart.c
    ./user/: MotorDriver.c GUA_Timer1_PWM.c
  group lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group psdk_core
    ./psdk/psdk_core/src/: psdk_aes.c psdk_crc.c psdk_debug.c psdk_md5.c psdk_proto.c psdk_proto_parse.c
  group psdk_arch
    ./psdk/psdk_arch/arch_baremetal/: psdk_arch_sys.c
  group psdk_upper
    ./psdk/psdk_upper/src/: psdk_app_func.c psdk_msg_subcribe.c psdk_payload_camera.c psdk_payload_gimbal.c psdk_upper.c
  group psdk_gui_test
    ./Application/psdk_test/: test_app_func.c test_msg_push.c test_payload_gimbal_emu.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
